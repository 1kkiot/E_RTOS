# Keil uVision project Demo_project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F071CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Demo_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F071xB
  c include: ..\Hal\Inc;..\Hal\Inc\Legacy;..\App;..\Base;..\Sys;..\User;..\Core;..\Config;..\Task;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\FreeRTOS\CMSIS_RTOS;..\debug;..\Memory
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group HAL
    ../Hal/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Config
    ../FreeRTos/: FreeRTOSConfig.h
  group Base
    ../Base/: arm_base_define.h
  group Sysclock
    ../Config/: sys_clock.c sys_clock.h
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Debug
    ../debug/: Debugprintf.c Debugprintf.h
  group User
    ../User/: main.c startup_stm32f071xb.s stm32f0xx_hal_conf.h stm32f0xx_it.c stm32f0xx_it.h system_stm32f0xx.c
  group Sys
    ../Sys/: Sysgpio.c Sysgpio.h Delay.c Delay.h Sysuart.c Sysuart.h
  group Memory
    ../Memory/: Fifo.c Fifo.h Memory.c Memory.h
  group App
    ../App/: Analysis.c Analysis.h Command.c Command.h Pack.c Pack.h Wifi.c Wifi.h WifiCon.c WifiCon.h WifiConfig.c WifiConfig.h ReCmd.c ReCmd.h Function.c Function.h
  group Task
    ../Task/: MyTask.c MyTask.h
  group ReadME
    ../ReadME/: ReadME.txt
