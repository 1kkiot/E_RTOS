# Keil uVision project F2_APP_project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F2_Demo_project +hex
  AfterMake: fromelf --bin !L --output Demo_project.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ..\HAL\STM32F2xx_HAL_Driver\Inc;..\HAL\STM32F2xx_HAL_Driver\Inc\Legacy;..\User;..\HAL;..\Core;..\Sys;..\RT_Thread\3.1.2\bsp;..\RT_Thread\3.1.2\include;..\RT_Thread\3.1.2\include\libc;..\Myfinsh;..\RT_Thread\3.1.2\components\drivers\include\drivers;..\RT_Thread\3.1.2\components\drivers\include;..\RT_Thread\3.1.2\components\finsh;..\Memory;..\debug;..\IAP;..\Task;..\EasyFlash
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x54000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ../HAL/: startup_stm32f207xx.s stm32f207xx.h system_stm32f2xx.c system_stm32f2xx.h
  group RT_Thread_libcpu
    ../RT_Thread/3.1.2/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group RT_Thread_src
    ../RT_Thread/3.1.2/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RT_Thread_finsh
    ../RT_Thread/3.1.2/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT_Thread_drivers
    ../RT_Thread/3.1.2/components/drivers/src/: completion.c
    ../RT_Thread/3.1.2/components/drivers/serial/: serial.c
  group RT_Thread_usart
    ../Myfinsh/: MyFinsh.c MyFinsh.h
  group HAL
    ../HAL/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c
  group Config
    ../User/: stm32f2xx_hal_conf.h
  group debug
    ../debug/: Debugprintf.c Debugprintf.h
  group Memory
    ../Memory/: Fifo.c Fifo.h Memory.c Memory.h
  group Sys
    ../Sys/: gpio.c gpio.h uart.c uart.h uart_irq.c uart_irq.h
  group User
    ../User/: main.c main.h stm32f2xx_hal_msp.c stm32f2xx_it.c stm32f2xx_it.h
  group IAP
    ../IAP/: IAP.c IAP.h
    ../EasyFlash/ymodem/: ymodem.c ymodem.h
  group EasyFlash
    ../EasyFlash/: stmflash.c stmflash.h
  group RT_Thread_bsp
    ../RT_Thread/3.1.2/bsp/: board.c board.h rtconfig.h
  group RT_Thread_task
    ../Task/: RunTask1.c RunTask1.h TaskInit.c TaskInit.h getcpu.c getcpu.h OSCmd.c OSCmd.h
  group ReadME
    ../ReadME/: ReadME.txt
