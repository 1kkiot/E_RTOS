# Keil uVision project F2_Demo_project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F2_Demo_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ..\HAL\STM32F2xx_HAL_Driver\Inc;..\HAL\STM32F2xx_HAL_Driver\Inc\Legacy;..\User;..\HAL;..\Core;..\Sys;..\ymodem
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ../HAL/: startup_stm32f207xx.s stm32f207xx.h system_stm32f2xx.c system_stm32f2xx.h
  group HAL
    ../HAL/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c
  group Config
    ../User/: stm32f2xx_hal_conf.h
  group Sys
    ../Sys/: gpio.c gpio.h uart.c uart.h stmflash.c stmflash.h
  group User
    ../User/: main.c main.h stm32f2xx_hal_msp.c stm32f2xx_it.c stm32f2xx_it.h
  group ymodem
    ../ymodem/: common.c common.h flash_if.c flash_if.h menu.c menu.h ymodem.c ymodem.h
