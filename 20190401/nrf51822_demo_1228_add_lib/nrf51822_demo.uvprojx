# Keil uVision project nrf51822_demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10000
  c include: .\App;.\Core;.\Start;.\Start\arm;.\Sys;.\User;.\SysLib\inc;.\Spi;.\Lib\drivers_nrf\delay;.\Lib\drivers_nrf\hal;.\Lib\drivers_nrf\nrf_soc_nosd;.\Lib\drivers_nrf\config;.\Lib\libraries\util;.\Lib\drivers_nrf\common;.\Lib\drivers_nrf\spi_slave
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Start
    ./Start/arm/: arm_startup_nrf51.s
    ./Start/: system_nrf51.c
  group SysLib
    ./SysLib/: nrf51822_demo.lib
    ./SysLib/inc/: containerror.h Fifo.h Thread.h
  group Spi
    ./Spi/: SPI.c SPI.h
    ./Lib/drivers_nrf/spi_slave/: nrf_drv_spis.c nrf_drv_spis.h
    ./Lib/drivers_nrf/common/: nrf_drv_common.c nrf_drv_common.h
    ./Lib/libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h
  group Sys
    ./Sys/: base.h Sys.c Sys.h time.c time.h uart.c uart.h gpio.c gpio.h Flash.c Flash.h wdt.c wdt.h
  group User
    ./User/: main.c radio_config.c radio_config.h
  group App
    ./App/: memory.c memory.h task.c task.h runflag.c runflag.h decrypt.c decrypt.h setting.c setting.h Analysis.c Analysis.h crc.c crc.h olddecrypt.c olddecrypt.h
  group ReadMe
    ./ReadMe/: ReadMe.txt
