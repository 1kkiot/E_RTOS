# Keil uVision project project_17xx.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1754 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x4000) IRAM2(0x2007C000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_17xx_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Lib\include;.\Core;.\App;.\Sys;.\mylib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Start
    ./User/: lpc17xx_libcfg.h LPC17xx_it.c LPC17xx_it.h LPC17xx.h
    ./Start/: startup_LPC17xx.s
  group Lib
    ./Lib/source/: lpc17xx_timer.c debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_systick.c lpc17xx_uart.c lpc17xx_pinsel.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_wdt.c
  group Mylib
    ./mylib/: Fifo.h Thread.h Mylib.lib
  group Sys
    ./Sys/: base.h runflag.c runflag.h gpio.c gpio.h time.c time.h uart.c uart.h delay.c delay.h wdt.c wdt.h
  group User
    ./User/: main.c system_LPC17xx.c system_LPC17xx.h
  group App
    ./App/: spi.c spi.h Analysis.c Analysis.h memory.c memory.h logic.c logic.h crc.c crc.h Bluetooth.c Bluetooth.h setting.c setting.h
  group ReadME
    ./ReadMe/: ReadMe.txt
