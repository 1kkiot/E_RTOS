# Keil uVision project stm407_demo_project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm407_demo_project +hex
  AfterMake: fromelf --bin !L --output stm407_demo_project.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\User;.\HAL_lib\STM32F4xx_HAL_Driver\Inc;.\HAL_lib\STM32F4xx_HAL_Driver\Inc\Legacy;.\Core;.\Sys;.\Base;.\App;.\Config;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS;.\Memory;.\Debug;.\jSON
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Base
    ./Base/: arm_base_define.h
  group Config
    ./Config/: stm32f4xx.h stm32f4xx_hal_conf.h stm32f407xx.h
    ./FreeRTOS/: FreeRTOSConfig.h
  group HAL_lib
    ./HAL_lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Debug
    ./Debug/: Debugprintf.c Debugprintf.h
  group User
    ./User/: main.c main.h startup_stm32f407xx.s stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group cjson
    ./jSON/: cJSON.c cJSON.h s2j.c s2j.h s2jdef.h test.c test.h
  group Sys
    ./Sys/: SysClock.c SysClock.h SysFlash.c SysFlash.h SysGpio.c SysGpio.h SysRtc.c SysRtc.h SysTime.c SysTime.h SysUart.c SysUart.h Delay.c Delay.h
  group Memory
    ./Memory/: Memory.c Memory.h Fifo.c Fifo.h
  group App
    ./App/: MyTask.c MyTask.h Analysis.c Analysis.h Command.c Command.h Wifi.c Wifi.h WifiCon.c WifiCon.h WifiConfig.c WifiConfig.h Pack.c Pack.h ReCmd.c ReCmd.h
  group ReadME
    ./ReadME/: ReadME.txt
